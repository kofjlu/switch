# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; STM32F407xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread/components/libc/compilers/common; libraries/HAL_Drivers; rt-thread/components/finsh; libraries/HAL_Drivers/config; rt-thread/components/libc/posix/io/stdio; board/ports; rt-thread/libcpu/arm/common; rt-thread/libcpu/arm/cortex-m4; .; libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Include; applications; rt-thread/components/libc/posix/ipc; rt-thread/components/drivers/include; libraries/STM32F4xx_HAL/CMSIS/Include; board; rt-thread/components/libc/compilers/common/extension; board/CubeMX_Config/Inc; rt-thread/components/libc/posix/io/poll; rt-thread/include; libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
    rt-thread/components/libc/compilers/dlib/: syscall_mem.c environ.c syscall_remove.c syscalls.c syscall_lseek.c syscall_close.c syscall_write.c syscall_read.c syscall_open.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/ipc/: dataqueue.c ringbuffer.c ringblk_buf.c waitqueue.c completion.c pipe.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_soft_i2c.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: mempool.c kservice.c components.c scheduler.c mem.c idle.c ipc.c thread.c object.c clock.c timer.c device.c irq.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
